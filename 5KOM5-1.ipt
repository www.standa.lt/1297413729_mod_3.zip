# Autodesk Inventor part: 5KOM5-1
## iProperties
Created: 2011-02
Part Number: 5KOM5-1
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
